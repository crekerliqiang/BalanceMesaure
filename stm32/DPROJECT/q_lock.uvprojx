# Keil uVision project q_lock.uvprojx, settings and files
target q_lock (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: q_lock +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\project;..\ALIBCORE\core;..\ALIBCORE\inc;..\ALIBCORE\src;..\USER;..\Si4463
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../USER/: main.c
  group driver
    ../USER/: delay.c gpio.c usart1.c measure.c
  group arithmetic
    ../USER/: systemString.c rc4.c decryptPwd.c decryptPwdV2.c passwordTool.c
  group stm32library
    ../ALIBCORE/core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
    ../ALIBCORE/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
